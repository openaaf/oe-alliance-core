SUMMARY = "Kodi Media Center PVR plugins"

PKGV = "${PV}"

KODIADDONPLUGIN = "mediaportal.tvserver"

require kodi-addon-pvr.inc
