CFLAGS += "-Wno-error=maybe-uninitialized"
