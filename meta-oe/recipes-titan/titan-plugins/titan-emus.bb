SUMMARY = "meta file for Titan Softcam"
inherit packagegroup

require conf/license/license-gplv2.inc

DEPENDS1 = "\
  titan-plugin-emus-oscam.latest \
"

PR = "r0"
