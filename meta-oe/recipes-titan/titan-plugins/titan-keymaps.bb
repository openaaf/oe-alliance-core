SUMMARY = "meta file for Titan Player Plugins"
inherit packagegroup

require conf/license/license-gplv2.inc

DEPENDS = "\
    titan-plugin-keymaps-neutrino \
"

PR = "r0"
