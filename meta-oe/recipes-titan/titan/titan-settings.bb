SUMMARY = "meta file for Titan Settings"
inherit packagegroup

require conf/license/license-gplv2.inc

DEPENDS = "\
    titan-plugin-settings-andy \
    titan-plugin-settings-bulldog.192.sat \
    "

PR = "r0"
