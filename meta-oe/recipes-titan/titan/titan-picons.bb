SUMMARY = "meta file for Titan Picons"
inherit packagegroup

require conf/license/license-gplv2.inc

DEPENDS = "\
    titan-plugin-picons-black3d.hotbird.13.0e \
    titan-plugin-picons-black3d.astra.19.2 \
    titan-plugin-picons-black3d.astra.23.5e \
    titan-plugin-picons-black.eutelsat.36.0e \
    titan-plugin-picons-gold.nugget.hotbird.13.0e \
    titan-plugin-picons-gold.nugget \
    titan-plugin-picons-gold.nugget.astra.23.5e \
    titan-plugin-picons-gold.nugget.astra.28.2e \
    titan-plugin-picons-kabelbw \
    titan-plugin-picons-kabeldblack3d \
    titan-plugin-picons-kabeldtransparent \
    titan-plugin-picons-spiegel \
    titan-plugin-picons-transparent.hotbird.13.0e \
    titan-plugin-picons-transparent \
    titan-plugin-picons-transparent.astra.23.5e \
    titan-plugin-picons-transparent.astra.28.2e \
    titan-plugin-picons-small.transparent \
    "

PR = "r0"
